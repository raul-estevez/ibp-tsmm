options:
  parameters:
    author: Raúl Estévez Gómez
    generate_options: qt_gui
    id: morse_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 24e3
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '600'
    low_cutoff_freq: '400'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_1_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/abby/uvsl/curso_gnuradio/diff.grc
    type: float
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/abby/uni/tsmm/ibp_tsmm/resources/good.grc
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/abby/uni/tsmm/ibp_tsmm/resources/convined.grc
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '100'
    max_iter: '4000'
    scale: 1/100
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/abby/uni/tsmm/ibp_tsmm/resources/convined.wav
    repeat: 'False'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: (0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333,0.000833333)
    type: fff
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: (3e3,-3e3)
    type: fff
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: note_0
  id: note
  parameters:
    note: Matched filter
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: First Derivative
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: Output of filter
    size: 1024*150
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    name: Output of matched filter
    size: 1024*150
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    name: First derivative (clock recovery)
    size: 1024*150
    srate: samp_rate
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: float
    update_time: '0.01'
    wintype: window.WIN_BLACKMAN
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_complex_to_mag_1_0, '0']
- [blocks_complex_to_mag_1_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_complex_to_mag_1_0, '0', virtual_sink_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_file_sink_0_0, '0']
- [blocks_moving_average_xx_0, '0', fir_filter_xxx_1, '0']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_wavfile_source_0, '0', hilbert_fc_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_waterfall_sink_x_1, '0']
- [fir_filter_xxx_0, '0', blocks_moving_average_xx_0, '0']
- [fir_filter_xxx_1, '0', blocks_file_sink_0, '0']
- [fir_filter_xxx_1, '0', qtgui_time_sink_x_1, '0']
- [hilbert_fc_0, '0', band_pass_filter_0, '0']
- [virtual_source_0, '0', fir_filter_xxx_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
